# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4, __FPU_PRESENT = 1,__FPU_USED =1,__CC_ARM
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\nfs;..\..\components\dfs\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\include\netif;..\..\components\rtgui\dialog;..\..\components\rtgui\include;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\STM32_USB_HOST_Library\Class\HID\inc;Libraries\STM32_USB_HOST_Library\Class\MSC\inc;Libraries\STM32_USB_HOST_Library\Core\inc;Libraries\STM32_USB_OTG_Driver\inc;applications;drivers;dsplib;powersystem_ui
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c cpuusage.c ftpd.c platform.c startup.c tcpserver.c
    ./netutils/: udpserver.c udpecho.c
  group Drivers
    drivers/: Adc_Driver.c GPIO.c board.c can_network.c ccmram_def.c delay.c enc28j60.c mylcd.c sdio_sd.c serial.c setup.c spi_flash_w25qxx.c stm32f20x_40x_spi.c stm32f4_rtc.c stm32f4xx_it.c stmflash.c touch_driver.c usart.c
    ./netutils/: tftp.c ping.c
    ./drivers/: http.c
  group DSP
    dsplib/: arm_fft_bin_data.c
    ./dsplib/: arm_cortexM4lf_math.lib
  group power_ui
    Interver_UI/: CRC_Check.c Grid_connected.c Interver_RTU.c Interver_load_ui.c Interver_window.c Save_data.c Scope.c Skeyboard.c User_panel.c application_mes.c demo_view_dc_buffer.c demo_view_slider.c file_view.c gui_app.c scope_analyze.c scope_setting.c system_direction.c view.c view_buffer_animation.c view_image.c win1_ui.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/nfs/: mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c dfs_nfs.c
    ../../components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c rpc_prot.c pmap.c xdr.c xdr_mem.c
  group DeviceDrivers
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group LwIP
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group RTGUI
    ../../components/rtgui/apps/: calibration.c
    ../../components/rtgui/common/: animation.c animation_engines.c asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_xpm.c matrix.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/dialog/: filedialog.c messagedialog.c
    ../../components/rtgui/server/: driver.c gesture.c mouse.c server.c topwin.c touch.c
    ../../components/rtgui/widgets/: box.c button.c caret.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c text_encoding.c textbox.c textview.c title.c widget.c window.c
